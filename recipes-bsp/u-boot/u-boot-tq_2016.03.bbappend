
SRCREV_tqma6q-nav-gui = "6f9af19725574331e5269bbb5f7e4e4caf3f61dc"
SRCBRANCH_tqma6q-nav-gui = "NAV-imx_v2016.03_4.1.15_2.0.0_ga"

COMPATIBLE_MACHINE = "(tqma6q-nav-gui)"
