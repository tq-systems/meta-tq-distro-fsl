
COMPATIBLE_MACHINE = "(tqma6q-mba6x-gui|tqma6dl-mba6x-gui|tqma6s-mba6x-gui)"
